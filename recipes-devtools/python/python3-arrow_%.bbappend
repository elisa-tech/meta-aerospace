# SPDX-License-Identifier: MIT
# Needed as a native dependency of python3-fprime-tools-native (fprime build tooling)
BBCLASSEXTEND += "native nativesdk"
